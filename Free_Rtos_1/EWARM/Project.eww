<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Free_Rtos_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
